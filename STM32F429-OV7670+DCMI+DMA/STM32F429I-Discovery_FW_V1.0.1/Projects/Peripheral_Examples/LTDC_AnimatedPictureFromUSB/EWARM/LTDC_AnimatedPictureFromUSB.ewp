# IAR project LTDC_AnimatedPictureFromUSB.ewp, settings and files
configuration LTDC_AnimatedPictureFromUSB (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324xG_EVAL; USE_USB_OTG_HS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F429I-Discovery; ..\..\..\..\Utilities\Common; ..\..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.bin
  ILINK.IlinkOutputFile: LTDC_AnimatedPictureFromUSB.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../: main.c stm32fxxx_it.c usb_bsp.c usbh_usr.c
  group FAT_FS
    ../: fattime.c
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c
  group STM32_EVAL
    ../../../../Utilities/Common/: lcd_log.c
  group STM32F4xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
    ../: system_stm32f4xx.c
  group STM32F4xx/STM32F429i-Discovery
    ../../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USB_Host/Class/MSC
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Host/Core
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
