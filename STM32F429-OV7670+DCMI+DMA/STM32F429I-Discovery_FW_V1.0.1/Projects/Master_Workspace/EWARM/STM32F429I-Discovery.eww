<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F429I-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FW_upgrade\EWARM\STM32F429I-Discovery_FW_Upgrade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_DMA\EWARM\ADC_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_DualModeInterleaved\EWARM\ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_TripleModeInterleaved\EWARM\ADC_TripleModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DAC_SignalsGeneration\EWARM\DAC_SignalsGeneration.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA2D_MemToMemWithBlending\EWARM\DMA2D_MemToMemWithBlending.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA2D_MemToMemWithPFC\EWARM\DMA2D_MemToMemWithPFC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI_Example\EWARM\EXTI_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_DualBoot\EWARM\FLASH_DualBoot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\FLASH_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_WriteProtection\EWARM\FLASH_WriteProtection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FMC_SDRAM\EWARM\FMC_SDRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FMC_SDRAM_LowPower\EWARM\FMC_SDRAM_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Example\EWARM\IWDG_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\LTDC_AnimatedPictureFromUSB\EWARM\LTDC_AnimatedPictureFromUSB.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\LTDC_ColorKeying\EWARM\LTDC_ColorKeying.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\LTDC_Display_2Layers\EWARM\LTDC_Display_2Layers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\MEMS_Example\EWARM\MEMS_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC_ClockConfig\EWARM\RCC_ClockConfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC_CSS\EWARM\RCC_CSS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\SysTick_Example\EWARM\SysTick_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWMOutput\EWARM\TIM_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\Touch_Panel\EWARM\Touch_Panel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Template\EWARM\Template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


