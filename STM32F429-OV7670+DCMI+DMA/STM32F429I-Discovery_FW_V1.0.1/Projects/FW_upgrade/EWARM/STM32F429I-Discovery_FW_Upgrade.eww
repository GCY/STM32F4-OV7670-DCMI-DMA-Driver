<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F429I-Discovery_FW_Upgrade.ewp</path>
  </project>
  <batchBuild/>
</workspace>


